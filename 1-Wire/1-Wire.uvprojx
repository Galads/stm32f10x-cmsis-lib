# Keil uVision project 1-Wire.uvprojx, settings and files
target 1-Wire (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1-Wire
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\UserCode;.\UserCode\inc;.\UserCode\scr
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserCode
    ./UserCode/scr/: 1-wire.c
    ./UserCode/example/: example.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
